# Keil uVision project SWM341_StdPeriph_Driver.uvprojx, settings and files
target SWM341 (6160000::V6.16::ARMCLANG)
  device: ARMCM33 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M33") ESEL ELITTLE
  output: SWM341_SFC +hex
  AfterMake: cmd.exe /C copy "out\%L" "out\@L.FLM"
  AfterMake: fromelf --text -a -c -o "$L@L.asm" "#L"
  c flags: Optim=2 v6Lang=3 v6LangP=1
  c include: .\CSL\CMSIS\CoreSupport;.\CSL\CMSIS\DeviceSupport;.\CSL\SWM341_StdPeriph_Driver;.\APP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\APP\linker.sct
  link misc: --diag_suppress L6305
  group APP
    ./APP/: FlashPrg.c FlashDev.c
  group CSL\StdPD
    ./CSL/SWM341_StdPeriph_Driver/: SWM341_port.c SWM341_gpio.c SWM341_sfc.c SWM341_flash.c
  group CSL\CMSIS
    ./CSL/CMSIS/DeviceSupport/: system_SWM341.c
